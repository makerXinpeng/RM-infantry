# Keil uVision project remote.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: remote +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F427X,__FPU_USED,__FPU_PRESENT,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\CORE;..\FWLIB\inc;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FUNCTION\DSP\Include;..\FUNCTION\user_lib;..\FUNCTION\hardware\rc;..\FUNCTION\hardware\can;..\FUNCTION\hardware\rng;..\FUNCTION\hardware\laser;..\FUNCTION\hardware\timer;..\FUNCTION\hardware\fric;..\FUNCTION\hardware\adc;..\FUNCTION\APP\pid;..\FUNCTION\APP\remote_control;..\FUNCTION\APP\CAN_receive;..\FUNCTION\APP\chassis_task;..\FUNCTION\APP\gimbal_task;..\FUNCTION\APP\shoot;..\FUNCTION\hardware\power_ctrl;..\APP;..\FUNCTION\judge_sys;..\FUNCTION\APP\INS_task;..\FUNCTION\hardware\spi;..\FUNCTION\hardware\exit_init;..\FUNCTION\AHRS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f427x.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group user_lib
    ../FUNCTION/user_lib/: user_lib.c
  group DSP
    ../FUNCTION/DSP/: arm_cortexM4lf_math.lib
  group hardware
    ../FUNCTION/hardware/rc/: rc.c
    ../FUNCTION/hardware/rng/: rng.c
    ../FUNCTION/hardware/can/: can.c
    ../FUNCTION/hardware/laser/: laser.c
    ../FUNCTION/hardware/timer/: timer.c
    ../FUNCTION/hardware/fric/: fric.c
    ../FUNCTION/hardware/power_ctrl/: power_ctrl.c
    ../FUNCTION/hardware/adc/: adc.c
    ../FUNCTION/hardware/spi/: spi.c
    ../FUNCTION/hardware/exit_init/: exit_init.c
  group APP
    ../FUNCTION/APP/remote_control/: remote_control.c
    ../FUNCTION/APP/pid/: pid.c
    ../FUNCTION/APP/shoot/: shoot.c
    ../APP/: Encoder.c Control_Task.c CloudMotor.c ChassisMotor.c
    ../FUNCTION/APP/INS_task/: INS_task.c
  group judge_system
    ../FUNCTION/judge_sys/: communicate.c data_fifo.c judgement_info.c JudgeSystem.c protocol.c
  group AHRS
    ../FUNCTION/AHRS/: AHRS_middleware.c ist8310driver.c ist8310driver_middleware.c mpu6500driver.c mpu6500driver_middleware.c AHRS.lib
